# IAR project K928mir.ewp, settings and files
configuration K928mir (ARM, debug)
  General.OGChipSelectEditMenu: STM32F746NG ST STM32F746NG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 6
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F746xx
  ICCARM.CCIncludePath2: ../Inc; ../!LAA; ../!LAA/TFT; ../!LAA/TFT/GLIB; ../!LAA/TFT/LED; ../!LAA/TFT/TEST; ../!LAA/SDRAM; ../!LAA/SDCARD; ../!LAA/UTILS; D:/LIUSHNIA/Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Drivers/STM32F7xx_HAL_Driver/Inc; D:/LIUSHNIA/Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Drivers/STM32F7xx_HAL_Driver/Inc/Legacy; D:/LIUSHNIA/Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Drivers/CMSIS/Device/ST/STM32F7xx/Include; D:/LIUSHNIA/Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Middlewares/Third_Party/FatFs/src; D:/LIUSHNIA/Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: K928mir.srec
  ILINK.IlinkOutputFile: K928mir.out
  ILINK.IlinkIcfFile: stm32f746xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group !LAA
    ../!LAA/: laa_user_code.c laa_user_code.h urls_thoughts.txt
  group !LAA/SDCard
    ../!LAA/SDCARD/: laa_sdcard.c laa_sdcard.h
  group !LAA/SDRAM
    ../!LAA/SDRAM/: laa_sdram.c laa_sdram.h
  group !LAA/TFT/GLIB
    ../!LAA/TFT/GLIB/: laa_tft_buffers.c laa_tft_buffers.h laa_tft_cache.c laa_tft_cache.h laa_tft_lib.c laa_tft_lib.h
  group !LAA/TFT/LED
    ../!LAA/TFT/LED/: laa_tft_led.c laa_tft_led.h
  group !LAA/TFT/TEST
    ../!LAA/TFT/TEST/: laa_tst_tft.c laa_tst_tft.h
  group !LAA/UTILS
    ../!LAA/UTILS/: laa_global_utils.h
  group Application/EWARM
    ./: startup_stm32f746xx.s
  group Application/User
    ../Src/: bsp_driver_sd.c fatfs.c main.c sd_diskio.c stm32f7xx_hal_msp.c stm32f7xx_it.c
  group Drivers/CMSIS
    ../Src/: system_stm32f7xx.c
  group Drivers/STM32F7xx_HAL_Driver
    ../../../../../Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dsi.c stm32f7xx_hal_flash.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rng.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c
  group Middlewares/FatFs
    ../../../../../Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../../../../../Soft/CubeMX/F7/STM32Cube_FW_F7_V1.9.0/Middlewares/Third_Party/FatFs/src/option/: syscall.c
